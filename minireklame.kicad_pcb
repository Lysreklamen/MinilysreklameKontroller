# Repository Lysreklamen/MinilysreklameKontroller

File README.md:

# Minilysreklamen

## Ting som må fikses til neste uke

- Endre footprint til led driveren (TLC5955RTQ) på kretskortet da qfn er vanskelig å oppdrive (Mulig chip shortage har skylden)
- Bom må gjennomgås sikkerlig før bestilling. I år hadde vi problemer med at vi ikke kunne oppdrive seriell kontrolleren blant annet
- Litt bedre plassering på designators hadde vært kjekt
- sp3483 er ikke lengere tilgjengelig og erstattes med MAX3483ECSA+T ser det ut som.

## KiCad design minireklame.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C12, C13, C14, C15: 100n; C_0805_HandSoldering
C8, C9: 9p; C_0805_HandSoldering
C10, C11: 22u; C_0805_HandSoldering
C16, C17, C18, C19: 47u; CP_Elec_6.3x7.7
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0805
IC1: ATXMEGA64A4U-A; TQFP-44_10x10mm_Pitch0.8mm
P0, P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15: CONN_01X04; JST_PH_B4B-PH-K_04x2.00mm_Straight
P17: Phoenix_508_2pos; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
P18: AVR-PUDI-6; IDC_Header_Straight_6pins
P19, P20: CONN_01X02; JST_PH_B2B-PH-K_02x2.00mm_Straight
Q1: 16MHz; Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering
R1, R2: 10k; R_0805_HandSoldering
R3, R4, R5, R6, R7, R8, R9, R10: 68; R_0805_HandSoldering
R11, R12: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: TLV1117-33CDCYR; SOT-223
U2: SP3483-EN-L; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: TLC5955; QFP_56_8x8mm_0.5mm_pitch

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C11.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), IC1.9 (VCC), IC1.19 (VCC), IC1.31 (VCC), IC1.39 (AVCC), P18.2, R2.1, U1.2 (VO), U2.8, U3.33
+5V: C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, P0.4, P1.4, P2.4, P3.4, P4.4, P5.4, P6.4, P7.4, P8.4, P9.4, P10.4, P11.4, P12.4, P13.4, P14.4, P15.4, R11.1, U1.3 (VI)
/LED1: IC1.28 (PE0/OC0A/SDA), R3.2
/LED2: IC1.29 (PE1/OC0B/XCK0/SCL), R4.2
/LED3: IC1.32 (PE2/OC0C/RXD0), R5.2
/LED4: IC1.33 (PE3/OC0D/TXD0), R6.2
/LED5: IC1.20 (PD0/OC0A), R7.2
/LED6: IC1.21 (PD1/OC0B/XCK0), R8.2
/LED7: IC1.22 (PD2/OC0C/RXD0), R9.2
/LED8: IC1.23 (PD3/OC0D/TXD0), R10.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, IC1.8 (GND), IC1.18 (GND), IC1.30 (GND), IC1.38 (GND), P17.2 (GND), P18.6, Q1.2, Q1.4, R1.2, R12.2, U1.1 (GND), U2.5, U3.8, U3.35
unnamed: C7.1, IC1.35 (~RESET~/PDI_CLK), P18.5, R2.2
unnamed: C8.1, IC1.36 (PR0/XTAL2/TOSC2), Q1.1
unnamed: C9.1, IC1.37 (PR1/XTAL1/TOSC1), Q1.3
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), R5.1
unnamed: D4.1 (K), R6.1
unnamed: D5.1 (K), R7.1
unnamed: D6.1 (K), R8.1
unnamed: D7.1 (K), R9.1
unnamed: D8.1 (K), R10.1
unnamed: IC1.13 (SCLOUT/TXD0/OC0BHS/OC0D/PC3), U3.38
unnamed: IC1.14 (~SS~/~OC0CLS~/OC1A/PC4), U3.34
unnamed: IC1.15 (MOSI/XCK1/OC0CHS/OC1B/PC5), U3.36
unnamed: IC1.16 (CLKRTC/MISO/RXD1/~OC0DLS~/PC6), U3.7
unnamed: IC1.17 (EVOUT/CLKOUT/SCK/TXD1/OC0DHS/PC7), U3.37
unnamed: IC1.24 (PD4/OC1A/~SS~), R12.1, U2.2
unnamed: IC1.25 (PD5/OC1B/XCK1/MOSI), R1.1, U2.3
unnamed: IC1.26 (PD6/D-/RXD1/MISO), R11.2, U2.1
unnamed: IC1.27 (PD7/D+/TXD1/SCK/CLKOUT/EVOUT), U2.4
unnamed: IC1.34 (PDI_DATA), P18.1
unnamed: P0.1, U3.42
unnamed: P0.2, U3.44
unnamed: P0.3, U3.43
unnamed: P1.1, U3.48
unnamed: P1.2, U3.50
unnamed: P1.3, U3.49
unnamed: P2.1, U3.51
unnamed: P2.2, U3.53
unnamed: P2.3, U3.52
unnamed: P3.1, U3.1
unnamed: P3.2, U3.3
unnamed: P3.3, U3.2
unnamed: P4.1, U3.39
unnamed: P4.2, U3.41
unnamed: P4.3, U3.40
unnamed: P5.1, U3.45
unnamed: P5.2, U3.47
unnamed: P5.3, U3.46
unnamed: P6.1, U3.54
unnamed: P6.2, U3.56
unnamed: P6.3, U3.55
unnamed: P7.1, U3.4
unnamed: P7.2, U3.6
unnamed: P7.3, U3.5
unnamed: P8.1, U3.32
unnamed: P8.2, U3.30
unnamed: P8.3, U3.31
unnamed: P9.1, U3.26
unnamed: P9.2, U3.24
unnamed: P9.3, U3.25
unnamed: P10.1, U3.17
unnamed: P10.2, U3.15
unnamed: P10.3, U3.16
unnamed: P11.1, U3.11
unnamed: P11.2, U3.9
unnamed: P11.3, U3.10
unnamed: P12.1, U3.29
unnamed: P12.2, U3.27
unnamed: P12.3, U3.28
unnamed: P13.1, U3.23
unnamed: P13.2, U3.21
unnamed: P13.3, U3.22
unnamed: P14.1, U3.20
unnamed: P14.2, U3.18
unnamed: P14.3, U3.19
unnamed: P15.1, U3.14
unnamed: P15.2, U3.12
unnamed: P15.3, U3.13
unnamed: P19.1, P20.1, U2.6
unnamed: P19.2, P20.2, U2.7

Notes on the sheet:
PWR
PDI
DMX I/O
close to ATXMEGA
close to SP3483
close to TLC5955
optional XTAL
junction close to SP3483
Support Capacitors for VLED, distribute on PCB
Values for support capacitors choosen based on stomach feeling...

Board: 2 copper layers, 100.0 x 50.0 mm, 64 parts (0 on the bottom side), 82 nets.

File minilysreklame_bom.txt:

C1-C7,C12-C15	100n			Capacitors_SMD:C_0805_HandSoldering				11	MC0805B104K500CT			1759265
C8,C9		9p			Capacitors_SMD:C_0805_HandSoldering				 2	MC0805N9R0D500CT			1759189
C10,C11		22u			Capacitors_SMD:C_0805_HandSoldering				 2	MC0805X226M6R3CT			1759415
C16-C19		47u			Capacitors_SMD:CP_Elec_6.3x7.7					 4	MCVVT016M470EA1L			2471850
R1,R2		10k			Resistors_SMD:R_0805_HandSoldering				 2	MCMR08X103 JTL				2073612
R3-R10		68			Resistors_SMD:R_0805_HandSoldering				 8	MCWR08X68R0FTL				2447707
D1-D8		LED Green		LEDs:LED_0805							 8	MCL-S270GC				1581242
U1		TLV1117-33CDCYR		TO_SOT_Packages_SMD:SOT-223					 1	TLV1117-33CDCYR				1494942		OV
not in stock!U2	SP3483-EN-L		Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm			 1	SP3483EN-L				1296640		!
U2		ADM3493ARZ		Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm			 1	ADM3493ARZ				1274164			
U3		TLC5955			tlc5955:QFP_56_8x8mm_0.5mm_pitch				 1	TLC5955DCA				2492346
IC1		ATXMEGA64A4U-A		Housings_QFP:TQFP-44_10x10mm_Pitch0.8mm				 1	ATXMEGA64A4U-AU				2443193		OV
P1-P16		CONN_01X04		Connectors_JST:JST_PH_B4B-PH-K_04x2.00mm_Straight		16	B4B-PH-K-S(LF)(SN)			9492437
P17		Screw_Terminal_1x02	Connectors_Terminal_Blocks:TerminalBlock_Pheonix_PT-3.5mm_2pol	 1	CTBP3051/2				2527545		Snorre
P18		AVR-PUDI-6		Connectors:IDC_Header_Straight_6pins				 1	M20-9980346				1022231
P19,P20		CONN_01X02		Connectors_JST:JST_PH_B2B-PH-K_02x2.00mm_Straight		 2	B2B-PH-K-S(LF)(SN)			9491856
Q1		16MHz			Crystals:Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering		 1	X1E0000210117 TSX-3225 16MHZ 9PF	2471850

## Commit log

2017-04-26 initial commit of current working project, not sure how things ended up in *-cache.lib and *-rescue.lib
2017-04-26 generating pdf output
2017-05-15 place PDI header
2017-05-15 tidying up junctions and moving 100n Cs for better readability
2017-05-15 pulldown for & !RE DE line
2017-05-15 fixing ATXMEGA TLC conncetion
2017-05-15 added optional XTAL
2017-05-15 DMX now with in and out
2017-05-15 chaning power terminal and renumbering connectors
2017-05-15 support C for VLED
2017-05-15 strobe LEDs placed (visual debugging)
2017-05-15 tlc5955.lib had sp3484 content for some reason
2017-05-15 removing minireklabe-rescue.lib and fixing pins in sp3483.lib
2017-05-15 updating pin numbers for QFN-56 variant of TLC5955
2017-05-15 adding QFN-56 to TLC5955 description
2017-05-15 rearranging pin positions of TLC5955 so simplify schematic
2017-05-15 annotating component IDs
2017-05-15 generating schematic.pdf for second review
2017-06-06 exchanging GSCLK and LAT connection
2017-06-06 Annotating footprints for C, R and ATXMEGA, QFN for TLC5955 needs different pitch
2017-06-06 adding JST GH BM series connector to all normal pin connectors
2017-06-06 Annotating footprints for electrolyte Cs, LEDs and crystal
2017-06-06 Assigning QFP_56_8x8mm_0.5mm_pitch footprint to TLC5955
2017-06-06 adding 4 more LEDs to strobbus, cause we might want to have them too
2017-06-06 missing footprint library reference
2017-06-06 netlist for schematic
2017-06-06 distributed all parts in pcb layout
2017-06-06 arranging parts roughly in board outline
2017-06-06 merging VDD and +5V net
2017-07-04 changed to 4 pin crystal schematic sign
2017-07-04 fixing mixed wires
2017-07-04 starting to route stuff...
2017-07-05 routing top layer finished, ground conn missing
2017-07-06 finalising review version of pcb layout
2017-07-06 pdf export
2017-07-06 commit of other project files to be in line with v20170706
2017-07-27 chainging track width out of TCL5955 and distributing traces better
2017-07-30 Gerber and Drill export
2017-07-30 placing vias again as footprint to avoid loss of net information and optimising part numbers on silk
2017-08-01 pdf output of schematic and pcb
2017-09-10 adding missing part values
2017-09-10 adding current bom, exchanging sp3483 with adm3493adz as that one is in stock and generating necessary parts from farnell list
2017-09-10 two things to remember
2017-10-17 initial add of fw
2017-10-17 add untested minireklamedriver
2017-10-17 it compiles!
2019-05-30 fixed connector designators to match pwm channel
2019-05-30 Fungerende og testet minireklamekontroller
2019-06-09 Updated schematic and generated netlist
    Corrected net labels for SP3483, and replaced 3mm terminal connector with pluggable 5mm terminal connector.
2019-06-09 Updated PCB from schematic
    No errors. Vias and ground plane dissappeared. Footprints and net labels should be checked against datasheets.
2019-07-17 New outlay
    Made new PCB outlay based on the new schematic.
2019-08-07 Updated Silkscreen
    Updated silkscreen for version control.
2019-08-07 Gerber and drill files
    Generated gerber and drill files. Uploaded to jlcpcb and verified that it looked ok.
2019-08-14 Fixed keepout area
    Fixed minor bug in keepout area.
2019-08-15 Virker trolig
2021-09-23 Updated with registered faults noticed in uka21 and added notes to later year
